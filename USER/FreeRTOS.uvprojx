# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\BSP\delay;..\HARDWARE\BSP\sys;..\HARDWARE\BSP\usart;..\HARDWARE\BSP\cjson;..\HARDWARE\DEVICES\led;..\HARDWARE\DEVICES\esp8266;..\HARDWARE\DEVICES\mqtt;..\HARDWARE\DEVICES\emqx;..\HARDWARE\CONFIG
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: README.TXT
  group BSP
    ../HARDWARE/BSP/delay/: delay.c
    ../HARDWARE/BSP/sys/: sys.c
    ../HARDWARE/BSP/usart/: usart.c
    ../HARDWARE/BSP/cjson/: cJSON.c
  group DEVICES
    ../HARDWARE/DEVICES/led/: bsp_led.c
    ../HARDWARE/DEVICES/esp8266/: bsp_esp8266.c
    ../HARDWARE/DEVICES/mqtt/: MqttKit.c
    ../HARDWARE/DEVICES/emqx/: bsp_emqx.c
